(* Logix 5000 Module export GS30A_CM_EIP1; software revision 37.00 *)

MODULES
   GS30A_CM_EIP1 : GS30A-CM-EIP1 (Ethernet 10.11.0.50, rev 1.1, StandardDataDriven RPI 250 ms)
END_MODULES
